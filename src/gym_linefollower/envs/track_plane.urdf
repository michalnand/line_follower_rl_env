Commit message: common

File: src/gym_linefollower/envs/track_plane.urdf (robot description, URDF)
Before this commit: robot world, 2 links, 1 joints
Links:
- link plane: geometry collision box size=10.0 10.0 0.01; visual box size=10.0 10.0 0.01
