Commit message: starting to write into ai gym

File: src/gym_line_follower/envs/track_plane.urdf (robot description, URDF)
Before this commit: robot world, 2 links, 1 joints
Links:
- link line: geometry visual mesh filename=./line.obj scale=1 1 1
